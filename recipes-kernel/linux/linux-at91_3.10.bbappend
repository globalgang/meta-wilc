COMPATIBLE_MACHINE_sama5d3_xplained = "sama5d3_xplained"

#ethernet port issue.
SRCREV = "8e5d023949cd657cae9298d6a1aad0a635cddc49"